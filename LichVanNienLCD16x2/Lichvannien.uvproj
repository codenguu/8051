# Keil uVision project Lichvannien.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Lichvannien +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.h main.c
    ../Lib/: Delay.c LCD16x2_cmd.c Rtc_Ds1307.c Soft_I2C.c
