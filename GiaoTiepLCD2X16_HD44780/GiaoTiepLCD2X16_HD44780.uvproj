# Keil uVision project GiaoTiepLCD2X16_HD44780.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GiaoTiepLCD2X16_HD44780 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.h main.c port.h
    ../Lib/: Delay.c LCD16x2_cmd.c
