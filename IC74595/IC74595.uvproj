# Keil uVision project IC74595.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: IC74595 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.h port.h main.c
    ../Lib/: IE74595_OUT.c Delay.c
